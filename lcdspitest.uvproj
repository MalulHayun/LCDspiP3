# Keil uVision project lcdspitest.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F380 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: LCDspiP3
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c init380.c LcdSpi20.LIB
